inherit cmake openrnd

OPENRND_REPO_NAME = "3rd.qamqp"
SRCREV = "387af4038e30b0663faf81ea41fd394dd71770ea"
LIC_FILES_CHKSUM = "file://${S}/license.html;md5=67c4f089200557f7b537243537b9b358"
LICENSE = "MIT"

PR = "r0"

# TODO maciek: add qt5 dependencies

# TODO maciek: remove test binaries


